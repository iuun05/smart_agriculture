# Keil uVision project main.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 DTH11.c dth11.h esp8266.h allh.h esp8266.c uart.c XPT2046.c SGP30.c delay.h delay.c SGP30.h uart.h XPT2046.h main.c
